# Keil uVision project Pokemon.uvproj, settings and files
target Pokemon (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Pokemon
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADC.c DAC.c Sound.c ST7735.c Timer0.c Timer1.c LCD.s Print.s random.s startup.s Pokemon.c Music.c Joystick.c Graphics.c Actions.c Inside.c Environment.c Trainer.c Images.c Red_House.c Maps.c PokeBattle.c PokemonInfo.h PokemonSprites.h BattleImages.c PokeStructs.c User.c Kid.c Actions.h ADC.h BattleImages.h DAC.h Environment.h Graphics.h Images.h Inside.h Joystick.h Kid.h LCD.h Maps.h Music.h PokeBattle.h PokeLib.h PokeStructs.h print.h random.h Red_House.h Sound.h ST7735.h Timer0.h Timer1.h tm4c123gh6pm.h Trainer.h User.h ProfOak.c PokemonInfo.c
  group ObjectCode
    ./: texas.o
