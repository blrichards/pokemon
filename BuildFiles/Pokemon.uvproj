# Keil uVision project Pokemon.uvproj, settings and files
target Pokemon (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Pokemon
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../: Actions.c BattleImages.c Graphics.c Joystick.c Maps.c PokeBattle.c Pokemon.c PokemonInfo.c PokeStructs.c ST7735.c Tiles.c Actions.h BattleImages.h Graphics.h Joystick.h LCD.h Maps.h PokeBattle.h PokeLib.h PokemonInfo.h PokemonSprites.h PokeStructs.h print.h random.h ST7735.h TExaS.h Tiles.h tm4c123gh6pm.h LCD.s random.s startup.o texas.o People.c People.h
